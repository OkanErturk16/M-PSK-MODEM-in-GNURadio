options:
  parameters:
    generate_options: qt_gui
    id: EXP4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: n_data
  id: variable
  parameters:
    value: '256'
  states: {}
- name: n_frame_sync
  id: variable
  parameters:
    value: '63'
  states: {}
- name: n_time_sync
  id: variable
  parameters:
    value: '64'
  states: {}
- name: n_zero
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: M_PSK_EMBED
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass circBuffer:\n    def __init__(self, len_max=int(1e6), data_type=np.float32):\n        self.len_max = len_max\n        self.data_type = data_type\n        self.buffer = np.zeros(self.len_max, dtype=self.data_type)\n        self.RD_ptr = 0\n        self.WRT_ptr = 0\n        self.elements_in_buffer = 0\n\n    def WRT(self, x):\n        #x: data (np.array)\n        len_x = len(x)\n        self.elements_in_buffer += len_x\n\n        if (len_x + self.WRT_ptr) < self.len_max:\n            self.buffer[self.WRT_ptr:(self.WRT_ptr+len_x)] = x\n            self.WRT_ptr += len_x\n\n        else:\n            len_x1 = self.len_max - self.WRT_ptr\n            len_x2 = len_x - len_x1\n            self.buffer[-len_x1:] = x[:len_x1]\n            self.buffer[:len_x2] = x[len_x1:]\n            self.WRT_ptr = len_x2\n\n    def RD(self, len_x):\n        self.elements_in_buffer -= len_x\n        if (len_x + self.RD_ptr) < self.len_max:\n            x = self.buffer[self.RD_ptr:(self.RD_ptr+len_x)]\n            self.RD_ptr += len_x\n        else:\n            x = np.zeros(len_x, dtype=self.data_type)\n            len_x1 = self.len_max - self.RD_ptr\n            len_x2 = len_x - len_x1\n\n            x[:len_x1] = self.buffer[-len_x1:]\n            x[len_x1:] = self.buffer[:len_x2]\n            self.RD_ptr = len_x2\n        return x\n\n    def is_RD_available(self, len_x):\n        if self.elements_in_buffer >= len_x:\n            return True\n        else:\n            return False\n\n    def is_WRT_available(self, x):\n        if (self.len_max - self.elements_in_buffer) >= len(x):\n            return True\n        else:\n            return False\n\n    def reset_buffer(self):\n        self.WRT_ptr = self.RD_ptr\n        self.elements_in_buffer = 0\n\n    def extend_buffer(self, len_extension):\n        self.buffer = np.concatenate((self.buffer[:(self.WRT_ptr+1)], np.zeros(\n            len_extension, dtype=self.data_type), self.buffer[(self.WRT_ptr+1):]))\n        if self.WRT_ptr < self.RD_ptr:\n            self.RD_ptr += len_extension\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self, m=4, n_symbol=100, n_zero=20, n_time_sync=128, n_frame_sync=63, os=4):\n\n        gr.sync_block.__init__(\n            self,\n            name=' My M-PSK Modulator',\n            in_sig=[],\n            out_sig=[np.complex64]\n        )\n\n        self.n_symbol = n_symbol       # number of symbols\n        self.n_zero = n_zero         # len of zero padding\n        self.n_time_sync = n_time_sync    # +-1 alternating sequence length\n        # Zadoff-Chu sequence length (odd values are better)\n        self.n_frame_sync = n_frame_sync\n        self.os = os                   # oversampling FACTOR\n        self.m = m                    # bit/symbol\n        self.M = int(2**m)            # M of M-PSK\n        self.constellation = np.exp( 1j*2.0*np.pi*np.arange(0, self.M)/self.M)  # constellation points\n        \n        # zero padding between the transmit pulses\n        self.zero_padding_seq = np.zeros(self.n_zero, dtype=np.complex64)\n        self.time_sync_seq = np.tile(np.array([-1, 1], dtype=np.complex64), int(n_time_sync/2))\n        self.frame_sync_seq = 1.4414*np.exp(-1j*np.pi*np.arange(self.n_frame_sync)\n                                     * (np.arange(self.n_frame_sync)+1)/self.n_frame_sync)\n        self.pilot_seq = 1j*np.array([-1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1], dtype=np.complex64)\n        \n        # it is predefined and will be used in \"bit_to_symbol_mapper\" method\n        self.power_list = 2**(np.arange(self.m))[:, np.newaxis]\n        \n        # the singal not consumed will be stored in this buffer\n        self.signal_buffer = circBuffer(int(1e6), data_type=np.complex64)\n\n    def bit_to_symbol_mapper(self, B):\n        d = np.sum(B*self.power_list, axis=0)\n        a = self.constellation[d]\n        return a\n\n    def pulse_train_generator(self, a):\n        data_plus_plot = np.concatenate((self.pilot_seq,\n                                        a[len(self.pilot_seq):-\n                                        len(self.pilot_seq)],\n                                        self.pilot_seq))\n\n        a = np.concatenate((self.zero_padding_seq,\n                            self.time_sync_seq,\n                            self.frame_sync_seq,\n                            data_plus_plot))\n\n        a_os = np.zeros(len(a)*self.os, dtype=np.complex64)\n        a_os[::self.os] = a\n        return a_os\n\n    def transmit_signal_generate(self):\n        st0 = np.random.get_state()\n        np.random.seed(0)\n        B = np.random.randint(0, high=2, size=(self.m, self.n_symbol))\n        np.random.set_state(st0)\n        a = self.bit_to_symbol_mapper(B)\n        a_os = self.pulse_train_generator(a)\n        return a_os\n\n    # This is the method triggered by the GNU Radio scheduler\n    def work(self, input_items, output_items):\n        len_out = len(output_items[0])\n\n        flag = True\n        while flag:\n            if not self.signal_buffer.is_RD_available(len_out):\n                generated_signal = self.transmit_signal_generate()\n                if self.signal_buffer.is_WRT_available(generated_signal):\n                    self.signal_buffer.WRT(generated_signal)\n                else:\n                    print('Buffer Dolu!')\n            else:\n                output_items[0][:] = self.signal_buffer.RD(len_out)\n                flag = False\n\n        return len(output_items[0])\n"
    m: '2'
    n_frame_sync: n_frame_sync
    n_symbol: n_data
    n_time_sync: n_time_sync
    n_zero: n_zero
    os: '8'
  states: {}
- name: PSF_filter
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: myLib.x
    type: ccc
  states: {}
- name: PSF_filter_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: myLib.x
    type: ccc
  states: {}
- name: THALV1_Tagged_stream_receiver_2
  id: THALV1_Tagged_stream_receiver
  parameters:
    multiplier: '1'
  states: {}
- name: THALV1_correlate_and_tag_0
  id: THALV1_correlate_and_tag
  parameters:
    n_data: n_data
    n_frame_sync: n_frame_sync
    threshold: '0.5'
  states: {}
- name: THALV1_myer_oerder_cpp_0
  id: THALV1_myer_oerder_cpp
  parameters:
    n_symbol: '64'
    os: '4'
  states: {}
- name: THALV1_tagged_stream_trimmer_0
  id: THALV1_tagged_stream_trimmer
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '3200000'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1+20/1e6*1e-5
    freq_offset: 0.0025/8
    noise_voltage: 0.03*0
    seed: '0'
    taps: '[0,0,0,1,0.]'
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    K: '1'
    LOS: 'True'
    N: '8'
    fDTs: 1/120000/4
    seed: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0.25'
    decim: '1'
    samp_rate: '1'
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-0.25'
    decim: '1'
    samp_rate: '1'
    taps: '[1]'
    type: ccc
  states: {}
- name: myLib
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      from gnuradio.filter import firdes

      os = 8
      rrc_filter_alpha = 0.5
      n_frame_sync     = 127
      MF_len           = 4




      #NRZ filter
      #x = np.ones(os,dtype = np.complex64)/np.sqrt(2)

      #RRC filter
      x = firdes.root_raised_cosine(25, os, 1, rrc_filter_alpha,MF_len*os)
      x = x/np.sqrt(np.sum(np.abs(x)**2))


      # Frame_sync_seq
      frame_sync_seq   = np.exp(-1j*np.pi*np.arange(n_frame_sync)*(np.arange(n_frame_sync)+1)/n_frame_sync)

      # Correlator filter taps
      corr_filter_taps = np.concatenate((np.zeros(n_frame_sync,dtype = np.complex64),np.ones(n_frame_sync,dtype = np.complex64)))


      snr_filter_taps = np.ones(8)/8
  states: {}
- name: note_0
  id: note
  parameters:
    note: RECEIVER
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '2400000000'
    dev_addr: '"name=USB01"'
    dev_args: '"name=USB01"'
    gain0: '0.7'
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '2400000000'
    dc_offs_enb0: '""'
    dev_addr: '"name=USB01"'
    dev_args: '"name=USB01"'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: channel_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel_in
  states: {}

connections:
- [M_PSK_EMBED, '0', blocks_throttle_0, '0']
- [PSF_filter, '0', freq_xlating_fir_filter_xxx_0, '0']
- [PSF_filter, '0', qtgui_freq_sink_x_0, '0']
- [PSF_filter_0, '0', THALV1_myer_oerder_cpp_0, '0']
- [THALV1_Tagged_stream_receiver_2, '0', qtgui_const_sink_x_0, '0']
- [THALV1_correlate_and_tag_0, '0', blocks_null_sink_0, '0']
- [THALV1_correlate_and_tag_0, '1', THALV1_tagged_stream_trimmer_0, '0']
- [THALV1_myer_oerder_cpp_0, '0', THALV1_correlate_and_tag_0, '0']
- [THALV1_tagged_stream_trimmer_0, '0', THALV1_Tagged_stream_receiver_2, '0']
- [blocks_tag_gate_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', PSF_filter, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [channels_fading_model_0, '0', channels_channel_model_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', PSF_filter_0, '0']
- [uhd_usrp_source_0, '0', blocks_tag_gate_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [virtual_source_1, '0', channels_fading_model_0, '0']

metadata:
  file_format: 1
